# Keil uVision project CKF.uvprojx, settings and files
target CKF (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LJT +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\Main;..\USER;..\CORE;..\FWLIB\inc;..\Periphery\IO;..\APP;..\Periphery\BT;..\Periphery\SysTick;..\Periphery\MP3;..\Periphery\YuYin;..\Periphery\PWM
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./Main/: common.c
  group CORE
    ../CORE/: core_cm3.c system_stm32f10x.c stm32f10x_it.c
    ../CORE/startup/: startup_stm32f10x_md.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_dma.c stm32f10x_sdio.c
  group Periphery
    ../Periphery/SysTick/: SysTick.c
    ../Periphery/MP3/: MP3.c
    ../Periphery/YuYin/: YuYin.c
    ../Periphery/PWM/: PWM.c
    ../Periphery/IO/: IO.c
    ../Periphery/BT/: BT.c
  group APP
    ../APP/: app.c
